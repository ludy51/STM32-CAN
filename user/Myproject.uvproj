# Keil uVision project Myproject.uvproj, settings and files
target MyProject (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Myproject +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\core;..\stm32f10x_lib\inc;..\self_lib\KEY;..\self_lib\LED;..\self_lib\TIMER;..\self_lib\sys;..\self_lib\delay;..\self_lib\usart;..\FreeRTOS\include;..\FreeRTOS;..\self_lib\MyInit;..\self_lib\ADC;..\self_lib\PWR;..\self_lib;..\self_lib\RTC;..\self_lib\NVIC;..\self_lib\EE_IIC;..\self_lib\FLASH_SPI;..\self_lib\SPI;..\self_lib\GPS;..\self_lib\STMFLASH;..\self_lib\DMA;..\self_lib\SIM900A;..\self_lib\CAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group self_lib
    ../self_lib/: includes.h
    ../self_lib/KEY/: key.c
    ../self_lib/LED/: led.c
    ../self_lib/delay/: delay.c
    ../self_lib/usart/: usart.c
    ../self_lib/TIMER/: timer.c
    ../self_lib/sys/: sys.c
    ../self_lib/MyInit/: MyInit.c
    ../self_lib/ADC/: adc.c
    ../self_lib/PWR/: pwr.c
    ../self_lib/RTC/: rtc.c
    ../self_lib/NVIC/: nvic.c
    ../self_lib/EE_IIC/: ee_iic.c
    ../self_lib/FLASH_SPI/: flash_spi.c
    ../self_lib/SPI/: spi.c
    ../self_lib/GPS/: GPS.c
    ../self_lib/STMFLASH/: stmflash.c
    ../self_lib/DMA/: dma.c
    ../self_lib/SIM900A/: sim900a.c
    ../self_lib/CAN/: can.c
  group stm32f10x_lib
    ../stm32f10x_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_md.s
  group FreeRTOS
    ../FreeRTOS/: croutine.c heap_2.c list.c port.c queue.c timers.c tasks.c
  group FreeRTOS/include
    ../FreeRTOS/include/: croutine.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
